FILESEXTRAPATHS:prepend := "${THISDIR}/weston-init:"

SRC_URI:append = " file://weston.ini"
