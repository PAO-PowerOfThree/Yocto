FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGE = "psplash-pao-img.h"
